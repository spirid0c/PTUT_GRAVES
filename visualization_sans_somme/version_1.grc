options:
  parameters:
    generate_options: qt_gui
    id: version_1
    output_language: python
    title: GRAVEs version IUT
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 143e6
  states: {}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '76'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dhebo/Desktop/ptut2026/files_usrp/usrp_30ECB27.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/dhebo/Desktop/ptut2026/files_usrp/usrp_310FCEE.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dhebo/Desktop/ptut2026/files_usrp/usrp_310FCEE.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/dhebo/Desktop/ptut2026/files_usrp/usrp_30ECB27.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 50e3
    decim: '200'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 2000, 50)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 50e3
    decim: '200'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 2000, 50)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/200
    fc: 143.05e6
    fftsize: '2048'
    type: complex
    ymax: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/200
    fc: 143.05e6
    fftsize: '2048'
    type: complex
    ymax: '-70'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/200
    fc: 143.05e6
    fftsize: '2048'
    int_max: '-85'
    int_min: '-120'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/200
    fc: 143.05e6
    fftsize: '2048'
    int_max: '-85'
    int_min: '-120'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=30ECB27"'
    gain0: gain_db
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_addr: '"serial=310FCEE"'
    gain0: gain_db
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_1, '0', blocks_throttle2_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [blocks_throttle2_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle2_1, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [uhd_usrp_source_0_0, '0', blocks_file_sink_1, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
